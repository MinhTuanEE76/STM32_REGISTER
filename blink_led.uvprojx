# Keil uVision project blink_led.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blink_led +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Driver\RCC;.\Driver\GPIO;.\Driver\AFIO;.\Driver\EXTI;.\Driver\SYSCFG;.\Driver\TIMER;.\Driver\UART;.\Driver\NVIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./Src/: main.c
  group Driver
    ./Driver/RCC/: rcc.c rcc.h
    ./Driver/GPIO/: gpio.c gpio.h
    ./Driver/SYSCFG/: syscfg.c syscfg.h
    ./Driver/EXTI/: exti.c exti.h type.h
    ./Driver/TIMER/: timer.c timer.h
    ./Driver/UART/: uart.c uart.h
    ./Driver/NVIC/: nvic.c nvic.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
